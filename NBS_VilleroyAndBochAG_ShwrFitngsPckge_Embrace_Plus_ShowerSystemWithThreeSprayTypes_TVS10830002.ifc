Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-04-08T09:34:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.30.41
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Fri Apr 08 09:34:28 2022* Host: NCL-PI02* Database: C:\Users\connm\AppData\Local\Temp\{3B21727A-E765-4C45-9CC0-A402F7F69369}\ifc* Database version: 5507* Database creation date: Fri Apr 08 09:34:28 2022* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Fri Apr 08 09:34:28 2022* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Fri Apr 08 09:34:28 2022* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowTerminal: EmbracePlusShowerSystemWithThreeSprayTypesTVS10830002, NBS_VilleroyAndBochAG_ShwrFitngsPckge_Embrace_PLUS_ShowerSystemWithThreeSprayTypes_TVS10830002:EmbracePlusShowerSystemWithThreeSprayTypesTVS10830002:84037
In: Level 1
Type - PredefinedType: SHOWER; Classification: Pr_40_20_87_75 (Uniclass2015); Material: NBS_VilleroyAndBochAG_Nozzle, NBS_VilleroyAndBochAG_Chrome
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VilleroyAndBochAG_ShowerFittingsPackage_Embrace_Plus_ShowerSystemWithThreeSprayTypes_TVS10830002; ManufacturerName: Villeroy & Boch AG; ManufacturerURL: https://pro.villeroy-boch.com; NBSCertification: www.nationalbimlibrary.com/cert/kw2ycvop; ProductInformation: n/a; Uniclass2015Title: Shower fittings package; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Version: Products v1.22; Version: 2
Type - NBS_Data - Approval: n/a; ContainsRedListMaterials: n/a; CountryOfMaterialOrigin: n/a; CountryOfProductManufacture: n/a; EmbodiedCarbon: n/a; FlowRateMaximum: 21.6 L/min; Form: Shower set with three spray types; IntegralAccessories: n/a; MaterialsBody: Brass; MaterialsFinishAndColour: Gloss chrome; Recyclability: n/a; RecycledContent: n/a; StandardsShowerHeads: n/a; StandardsShowerHoses: n/a; StandardsShowerMixers: n/a; WaterSupplyTemperatureMaximum: n/a
Type - IFC - IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: n/a; Material: n/a; ModelNumber: TVS10830002; ModelReference: Embrace Plus Shower System With Three Spray Types TVS10830002; Name: ShowerFittingsPackage_Embrace_Plus_ShowerSystemWithThreeSprayTypes_TVS10830002_VilleroyAndBochAG; NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; Barcode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
